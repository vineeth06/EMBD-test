# Keil uVision project blnkytst.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM1 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M1") CLOCK(12000000) ESEL ELITTLE
  output: blnkytst
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:Startup 2.0.3
